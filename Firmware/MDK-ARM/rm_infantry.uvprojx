# Keil uVision project rm_infantry.uvprojx, settings and files
target rm_infantry (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: rm_infantry +hex
  AfterMake: fromelf.exe  --bin -o ./bin/test.bin ./rm_infantry/rm_infantry.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F427xx
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FatFs/src/drivers;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Middlewares/Third_Party/FatFs/src;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Drivers/CMSIS/Include;.\app;.\bsp;.\rmlib;.\other_lib;..\MDK-ARM
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c cc936.c
  group CMSIS
    ../Src/: system_stm32f4xx.c
  group MDK-ARM
    ./: startup_stm32f427xx.s
  group STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_uart.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rtc.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_flash.c stm32f4xx_hal_cortex.c
  group Library
    ../Src/: rtc.c tim.c fatfs.c spi.c stm32f4xx_hal_timebase_TIM.c sdio.c stm32f4xx_hal_msp.c dma.c bsp_driver_sd.c gpio.c
  group FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c tasks.c event_groups.c timers.c queue.c list.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group main
    ../Src/: usart.c stm32f4xx_it.c freertos.c can.c main.c
    ./app/: sys_config.h test.c init.c test.h
  group UserBsp
    ./bsp/: bsp_io.c bsp_can.c bsp_uart.c bsp_imu.c bsp_flash.c
    ./app/: cpu_utils.c
  group RmLib
    ./rmlib/: pid.c ramp.c data_fifo.c
  group Doc
    ../Doc/: read_me.txt
  group Debug
    ./app/: detect_task.c
    ./rmlib/: calibrate.c calibrate.h
  group ControlTask
    ./app/: RemoteTask.c RemoteTask.h chassis_task.c imu_task.c
    ./: can_send_task.c can_send_task.h gimbal_task.c gimbal_task.h shoot_task.c shoot_task.h
  group CommunicationTask
    ./app/: Serial_Debug.c
    ./: PC_communication_task.c PC_communication_task.h protocol.c protocol.h
    ./rmlib/: infantry_info.h
